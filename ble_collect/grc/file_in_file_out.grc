<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>file_to_file_without_buffer</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/Users/mmohamoud/software_defined_radios/file_in_file_out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/Users/mmohamoud/software_defined_radios/filename</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
