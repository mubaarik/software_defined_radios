<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gr_ble</value></param>
<param><key>author</key><value>Jan Wagner</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Bluetooth LE Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ble_base_freq</value></param>
<param><key>value</key><value>2402e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ble_channel</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ble_channel_spacing</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff_freq</value></param>
<param><key>value</key><value>850e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>ble_base_freq+(ble_channel_spacing * ble_channel)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmsk_gain_mu</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmsk_mu</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmsk_omega_limit</value></param>
<param><key>value</key><value>0.035</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmsk_sps</value></param>
<param><key>value</key><value>int(sample_rate / data_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lowpass_filter</value></param>
<param><key>value</key><value>firdes.low_pass(1, sample_rate, cutoff_freq, transition_width, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>squelch_threshold</value></param>
<param><key>value</key><value>-70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition_width</value></param>
<param><key>value</key><value>300e3</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>.1</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>-200</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/Users/mmohamoud/software_defined_radios/ble_collect/demodulated_signal</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_gfsk_demod</key>
<param><key>id</key><value>digital_gfsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>4</value></param>
<param><key>sensitivity</key><value>1.0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_lp</value></param>
<param><key>center_freq</key><value>-freq_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>taps</key><value>lowpass_filter</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>message_sink</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>maxoutbuf</key><value>65999</value></param>
<param><key>minoutbuf</key><value>6583</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>60</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>unpacked_to_packed</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink</value></param>
</block>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_lp</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_demod_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_demod_0</source_block_id><sink_block_id>unpacked_to_packed</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_lp</source_block_id><sink_block_id>digital_gfsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>message_sink</source_block_id><sink_block_id>virtual_sink</sink_block_id><source_key>msg</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>unpacked_to_packed</source_block_id><sink_block_id>message_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
